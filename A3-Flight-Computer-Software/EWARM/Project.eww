<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\A3-Flight-Computer-Software.ewp</path>
  </project>
  <batchBuild />
</workspace>
